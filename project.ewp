# IAR project project.ewp, settings and files
configuration rtthread (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: RT_USING_DLIBC; STM32F407xx; __RTTHREAD__; USE_HAL_DRIVER
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: libraries\HAL_Drivers\config; rt-thread\include; libraries\HAL_Drivers; packages\button-v1.0.1; rt-thread\libcpu\arm\common; rt-thread\libcpu\arm\cortex-m4; libraries\STM32F4xx_HAL\CMSIS\Include; rt-thread\components\finsh; .; applications; rt-thread\components\libc\posix\io\poll; rt-thread\components\drivers\include; board; libraries\STM32F4xx_HAL\STM32F4xx_HAL_Driver\Inc; rt-thread\components\libc\posix\ipc; board\CubeMX_Config\Inc; rt-thread\components\libc\compilers\common\extension; rt-thread\components\libc\posix\io\stdio; libraries\STM32F4xx_HAL\CMSIS\Device\ST\STM32F4xx\Include; rt-thread\components\libc\compilers\common; packages\ssd1306-latest\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../../rtthread.bin
  ILINK.IlinkOutputFile: rtthread.out
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: main.c
  group button_drive
    packages/button-v1.0.1/: button.c
  group Compiler
    rt-thread/components/libc/compilers/common/: stdlib.c time.c
    rt-thread/components/libc/compilers/dlib/: syscall_close.c syscall_open.c syscalls.c environ.c syscall_lseek.c syscall_mem.c syscall_write.c syscall_remove.c syscall_read.c
  group CPU
    rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m4/: context_iar.S cpuport.c
  group DeviceDrivers
    rt-thread/components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    rt-thread/components/drivers/ipc/: pipe.c ringblk_buf.c completion.c workqueue.c dataqueue.c ringbuffer.c waitqueue.c
    rt-thread/components/drivers/misc/: adc.c rt_drv_pwm.c pin.c
    rt-thread/components/drivers/serial/: serial.c
  group Drivers
    libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f407xx.s
    board/CubeMX_Config/Src/: stm32f4xx_hal_msp.c
    board/: board.c
    libraries/HAL_Drivers/: drv_gpio.c drv_soft_i2c.c drv_pwm.c drv_adc.c drv_usart.c drv_common.c
  group Finsh
    rt-thread/components/finsh/: shell.c msh.c cmd.c
  group Kernel
    rt-thread/src/: idle.c kservice.c irq.c components.c ipc.c thread.c timer.c device.c mempool.c scheduler.c mem.c clock.c object.c
  group Libraries
    libraries/STM32F4xx_HAL/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_lptim.c stm32f4xx_hal_adc.c stm32f4xx_hal_uart.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_usart.c stm32f4xx_hal_crc.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rng.c stm32f4xx_hal_cortex.c stm32f4xx_hal_cryp.c stm32f4xx_hal.c stm32f4xx_hal_i2c.c stm32f4xx_hal_cec.c stm32f4xx_hal_gpio.c
    libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group ssd1306
    packages/ssd1306-latest/src/: ssd1306_fonts.c ssd1306.c
